# Keil uVision project SmartHome_F407.uvprojx, settings and files
target SmartHome_F407 (6220000::V6.22::ARMCLANG)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: SmartHome_F407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,SH_MCU_F407,SMARTHOME_APP_TARGET
  c misc: -std=gnu99
  c include: ..;..\1_App;..\2_Device;..\3_Protocol;..\4_MiddleWare;..\5_Platform;..\6_ModuleDrives;..\7_HAL\CMSIS\Include;..\7_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\7_HAL\STM32F4xx_HAL_Driver\Inc;..\7_HAL\STM32F4xx_HAL_Driver\Inc\Legacy;..\8_Core;..\4_MiddleWare\FreeRTOS-Kernel\include;..\4_MiddleWare\FreeRTOS-Kernel\portable\MemMang;..\4_MiddleWare\FreeRTOS-Kernel\portable\GCC\ARM_CM4F;..\3_Protocol\MQTTClient-C\src;..\3_Protocol\MQTTClient-C\src\FreeRTOS;..\3_Protocol\MQTTPacket\src
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\\smarthome_f407_app_a.sct
  group App
    ../1_App/: main.c app_key.c app_led.c app_gateway.c app_sensor.c app_display.c app_alarm.c app_storage.c app_watchdog.c
    ../: config.c smarthome_state.c log.c
  group Device
    ../2_Device/: dev_io.c dev_net.c dev_sensor.c dev_display.c dev_storage.c
  group MiddleWare/FreeRTOS
    ../4_MiddleWare/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../4_MiddleWare/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../4_MiddleWare/FreeRTOS-Kernel/portable/GCC/ARM_CM4F/: port.c
  group Platform
    ../5_Platform/: platform_io.c platform_net.c platform_sensor.c platform_display.c platform_storage.c platform_backup.c
  group ModuleDrives
    ../6_ModuleDrives/: driver_buffer.c driver_led_key.c driver_dbg.c driver_net.c driver_hal_timebase.c driver_dht11.c driver_display.c driver_i2c.c driver_oled_ssd1306.c driver_light.c driver_w25qxx.c
  group HAL
    ../7_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_spi.c
  group Core
    ../8_Core/: stm32f4xx_hal_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c fault_diag.c
    ./: startup_stm32f407xx.s
target SmartHome_F407_B (6220000::V6.22::ARMCLANG)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: SmartHome_F407_B +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,SH_MCU_F407,SMARTHOME_APP_TARGET
  c misc: -std=gnu99
  c include: as above
  memory RVCT4: ROM 0x8080000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\\smarthome_f407_app_b.sct
