# Keil uVision project Bootloader_F407.uvprojx, settings and files
target Bootloader_F407 (6220000::V6.22::ARMCLANG)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: Bootloader_F407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,SH_MCU_F407
  c misc: -std=gnu99
  c include: ..;..\bootloader;..\7_HAL\CMSIS\Include;..\7_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\7_HAL\STM32F4xx_HAL_Driver\Inc;..\7_HAL\STM32F4xx_HAL_Driver\Inc\Legacy;..\8_Core
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Bootloader
    ../bootloader/: bootloader_main.c bootloader_ota.c bootloader_uart.c bootloader_flash.c bootloader_metadata.c bootloader_it.c
  group HAL
    ../7_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c
  group Core
    ../8_Core/: system_stm32f4xx.c stm32f4xx_hal_conf.h
    ./: startup_stm32f407xx.s
